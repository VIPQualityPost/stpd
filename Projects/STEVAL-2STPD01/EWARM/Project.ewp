# IAR project Project.ewp, settings and files
configuration Project (ARM, debug)
  General.OGChipSelectEditMenu: STM32G071KB ST STM32G071KB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32G071xx; USE_HAL_DRIVER; USE_FULL_LL_DRIVER; USE_STM32G0XX_NUCLEO; _SRC; _RTOS; USBPDCORE_LIB_PD3_FULL; USBPD_PORT_COUNT=2; _TRACE; _GUI_INTERFACE; _PPS=USBPD_FALSE; _SRC_CAPA_EXT=USBPD_FALSE; _SNK_CAPA_EXT=USBPD_FALSE; _ALERT=USBPD_FALSE; _BATTERY=USBPD_FALSE; _STATUS=USBPD_FALSE; _MANU_INFO=USBPD_FALSE; _DATA_ROLE_SWAP_DISABLED; NUCLEO_MB1360A; TCPP0203_SUPPORT; USE_PM; USE_PS
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\Drivers\CMSIS\Device\ST\STM32G0xx\Include; ..\..\..\Drivers\CMSIS\Include; ..\..\..\Drivers\STM32G0xx_HAL_Driver\Inc; ..\..\..\Drivers\BSP\Components\stpd01; ..\..\..\Drivers\BSP\Components\tcpp0203; ..\..\..\Drivers\BSP\STM32G0xx_Nucleo; ..\..\..\Drivers\BSP\STEVAL-2STPD01; ..\..\..\Middlewares\ST\STM32_USBPD_Library\Core\inc; ..\..\..\Middlewares\ST\STM32_USBPD_Library\Devices\STM32G0xx\inc; ..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM0; ..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\Utilities\PowerMonitor; ..\..\..\Utilities\PowerSharing; ..\..\..\Utilities\TRACER_EMB; ..\..\..\Utilities\GUI_INTERFACE
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc; ..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include
  OBJCOPY.OOCOutputFile: STSW-2STPD01_v1.0.0.bin
  ILINK.IlinkOutputFile: STSW-2STPD01.out
  ILINK.IlinkConfigDefines: __ICFEDIT_size_cstack__=0x400; __ICFEDIT_size_heap__=0x2000
  ILINK.IlinkIcfFile: stm32g071xx_flash.icf
  ILINK.IlinkExtraOptions: --basic_heap
  ILINK.IlinkAdditionalLibs: ..\..\..\Middlewares\ST\STM32_USBPD_Library\Core\lib\USBPDCORE_PD3_FULL_CM0PLUS_wc32.a; ..\..\..\Utilities\PowerSharing\lib\USBPD_PowerSharing.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: stm32g071xx_flash.icf
    ../Src/: system_stm32g0xx.c
  group Application/User
    ../Src/: main.c stm32g0xx_it.c usbpd.c usbpd_dpm_user.c usbpd_power_monitor_app.c usbpd_power_sharing_app.c usbpd_pwr_if.c
  group Application/VIF
    ../VIF/: STMicroelectronics__STEVAL-2STPD01__V1.0__0000.xml
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components/stpd01
    ../../../Drivers/BSP/Components/stpd01/: Release_Notes.md stpd01.c stpd01_reg.c
  group Drivers/BSP/Components/tcpp0203
    ../../../Drivers/BSP/Components/tcpp0203/: tcpp0203.c tcpp0203_reg.c
  group Drivers/BSP/NUCLEO
    ../../../Drivers/BSP/STM32G0xx_Nucleo/: stm32g0xx_nucleo.c
  group Drivers/BSP/STEVAL-2STPD01
    ../../../Drivers/BSP/STEVAL-2STPD01/: steval_2stpd01.c steval_2stpd01.h steval_2stpd01_bus.c steval_2stpd01_bus.h steval_2stpd01_conf.h steval_2stpd01_errno.h steval_2stpd01_stpd01.c steval_2stpd01_stpd01.h steval_2stpd01_stpd01_conf.h steval_2stpd01_tcpp02.c steval_2stpd01_tcpp02.h steval_2stpd01_tcpp02_conf.h steval_2stpd01_usbpd_pwr.c steval_2stpd01_usbpd_pwr.h
  group Drivers/CMSIS
    ../../../Drivers/CMSIS/Device/ST/STM32G0xx/Source/Templates/iar/: startup_stm32g071xx.s
  group Drivers/HAL
    ../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal_dma.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_lptim.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_rtc.c stm32g0xx_hal_rtc_ex.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_ll_dac.c stm32g0xx_ll_dma.c stm32g0xx_ll_gpio.c stm32g0xx_ll_lpuart.c stm32g0xx_ll_rcc.c stm32g0xx_ll_ucpd.c stm32g0xx_ll_usart.c stm32g0xx_ll_utils.c
  group Middlewares/ST/STM32_USBPD_Library/Core
    ../../../Middlewares/ST/STM32_USBPD_Library/Core/src/: usbpd_dpm_core.c usbpd_trace.c
  group Middlewares/ST/STM32_USBPD_Library/Devices/STM32G0xx
    ../../../Middlewares/ST/STM32_USBPD_Library/Devices/STM32G0XX/src/: usbpd_cad_hw_if.c usbpd_hw.c usbpd_hw_if_it.c usbpd_phy.c usbpd_phy_hw_if.c usbpd_pwr_hw_if.c usbpd_timersserver.c
  group Middlewares/Third_Party/FreeRTOS
    ../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
  group Middlewares/Third_Party/FreeRTOS/CMSIS_RTOS
    ../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/Third_Party/FreeRTOS/portable
    ../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM0/: port.c portasm.s
  group Utilities/EMB_TRACER
    ../../../Utilities/TRACER_EMB/: tracer_emb.c tracer_emb_hw.c
  group Utilities/GUI_INTERFACE
    ../../../Utilities/GUI_INTERFACE/: bsp_gui.c data_struct_tlv.c gui_api.c
  group Utilities/PowerMonitor
    ../../../Utilities/PowerMonitor/: usbpd_power_monitor.c usbpd_power_monitor.h
  group Utilities/PowerSharing
    ../../../Utilities/PowerSharing/: usbpd_power_sharing.h
